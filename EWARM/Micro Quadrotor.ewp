# IAR project Micro Quadrotor.ewp, settings and files
configuration Micro Quadrotor Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; STM32F103_MD
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ..\Quadrotor\Applications; ..\Quadrotor\Drivers; ..\Quadrotor\Math
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Micro Quadrotor.srec
  ILINK.IlinkOutputFile: Micro Quadrotor Configuration.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group Application/User
    ../Src/: dma.c gpio.c i2c.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Quadrotor/Applications
    ../Quadrotor/Applications/: Quad_AtSensor.cpp Quad_AtSensor.h Quad_Communication.h Quad_Config.cpp Quad_Config.h Quad_DT.cpp Quad_DT.h Quad_Filter.cpp Quad_Filter.h Quad_FlyControl.cpp Quad_FlyControl.h Quad_IMU.cpp Quad_IMU.h Quad_Motor.cpp Quad_Motor.h Quad_Param.cpp Quad_Param.h Quad_PID.cpp Quad_PID.h Quad_RC.cpp Quad_RC.h Quad_Scheduler.cpp Quad_Scheduler.h
  group Quadrotor/Drivers
    ../Quadrotor/Drivers/: board.c board.h Quad_Drv_EEPROM.c Quad_Drv_EEPROM.h Quad_Drv_LED.cpp Quad_Drv_LED.h Quad_Drv_MPU6050.cpp Quad_Drv_MPU6050.h Quad_Drv_Nrf24l01.cpp Quad_Drv_Nrf24l01.h Quad_Drv_PWM.cpp Quad_Drv_PWM.h Quad_Drv_Tick.cpp Quad_Drv_Tick.h Quad_Drv_Uart.cpp Quad_Drv_Uart.h
  group Quadrotor/Math
    ../Quadrotor/Math/: Quad_Math.cpp Quad_Math.h Quad_Matrix3.cpp Quad_Matrix3.h Quad_Quaternion.cpp Quad_Quaternion.h Quad_Rotations.h Quad_Vector3.cpp Quad_Vector3.h
